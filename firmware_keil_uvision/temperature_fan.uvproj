# Keil uVision project temperature_fan.uvproj, settings and files
target Target 1 (MCS-51)
  device: ADE5566 Analog Devices
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xF7FF) XRAM(0-0x7FF) CLOCK(32768)
  output: temperature_fan +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: START_AD.A51 temperature_fan.c
